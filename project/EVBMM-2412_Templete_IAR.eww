<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EVBMM-2412_Templete_IAR.ewp</path>
  </project>
  <batchBuild/>
</workspace>


