# IAR project EVBMM-2412_Templete_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 Freescale KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: TRK_KEA128; CPU_KEA128; IAR
  ICCARM.CCIncludePath2: ..\common; ..\cpu\headers; ..\cpu; ..\platforms; ..\users\inc; ..\peripher_drivers\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EVBMM-2412_Templete_IAR.srec
  ILINK.IlinkOutputFile: EVBMM-2412_Templete_IAR.out
  ILINK.IlinkIcfFile: ..\linker_files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h typedef.h uif.c uif.h
  group cpu
    ../cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h system_SKEAZ1284.c system_SKEAZ1284.h vectors.c vectors.h
  group cpu/headers
    ../cpu/headers/: SKEAZ1284.h
  group linker_files
    ../linker_files/: 128KB_Pflash.icf KEAZ128xxx4.icf
  group peripher_drivers/inc
    ../peripher_drivers/inc/: GPIO_Driver.h MSCAN_Driver.h SPI_Driver.h Systick_Driver.h
  group peripher_drivers/src
    ../peripher_drivers/src/: GPIO_Driver.c MSCAN_Driver.c SPI_Driver.c Systick_Driver.c
  group users/inc
    ../users/inc/: ISR.h
  group users/src
    ../users/src/: ISR.c main.c
